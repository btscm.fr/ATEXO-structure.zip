Properties of the parts of a building model (IFC2X3)

# File
File name: C:/Users/a.demas.DOMARN/AppData/Local/Temp/IFC_DB_22\db.IFCREPOSITORY.IFCMODEL
Time: 2016-07-13T10:25:50
Author: ANONYMOUS USER
Organization: ANONYMOUS ORGANISATION
Written by: The EXPRESS Data Manager Version 5.02.0110.01 : 14 Aug 2014
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.01 : 14 Aug 2014 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 13 10:25:50 2016 * Host: UCN-22 * Database: C:/Users/a.demas.DOMARN/AppData/Local/Temp/IFC_DB_22\db * Database version: 5507 * Database creation date: Wed Jul 13 10:25:38 2016 * Schema: IFC2X3 * Model: IFCREPOSITORY.IFCMODEL * Model creation date: Wed Jul 13 10:25:38 2016 * Header model: * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5714 : Permanent license. Expiry date: * EDMstepFileFactory options: 00

# IfcBuildingStorey, __Cdwk_Undefined__
Elevation: 10 mm

# IfcBeam (477)
In: __Cdwk_Undefined__
Name | Description
48 x Plat garde-corps | Cdwk_ProdNb: 11 / Cdwk_MatName: Acier 4.6
36 x Traverse | Cdwk_ProdNb: 57 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 49 / Cdwk_MatName: Acier 4.6
9 x Main courante | Cdwk_ProdNb: 20 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 119 / Cdwk_MatName: Acier 4.6
3 x Arbal?trier | Cdwk_ProdNb: 163 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 191 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 25 / Cdwk_MatName: Acier 4.6
9 x Longeron | Cdwk_ProdNb: 56 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 189 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 190 / Cdwk_MatName: Acier 4.6
4 x Lisse | Cdwk_ProdNb: 137 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 74 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 54 / Cdwk_MatName: Acier 4.6
2 x Montant | Cdwk_ProdNb: 122 / Cdwk_MatName: Acier 4.6
4 x Mur | Cdwk_ProdNb: 0 / Cdwk_MatName: B?ton
2 x Diagonale | Cdwk_ProdNb: 75 / Cdwk_MatName: Acier 4.6
2 x Montant | Cdwk_ProdNb: 93 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 41 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 24 / Cdwk_MatName: Acier 4.6
3 x Lisse | Cdwk_ProdNb: 120 / Cdwk_MatName: Acier 4.6
4 x Panne | Cdwk_ProdNb: 168 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 97 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 100 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 109 / Cdwk_MatName: Acier 4.6
3 x Poteau | Cdwk_ProdNb: 82 / Cdwk_MatName: Acier 4.6
2 x Poteau | Cdwk_ProdNb: 174 / Cdwk_MatName: Acier 4.6
3 x Panne | Cdwk_ProdNb: 140 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 26 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 194 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 9 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 143 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 44 / Cdwk_MatName: Acier 4.6
3 x Suspente | Cdwk_ProdNb: 63 / Cdwk_MatName: Acier 4.6
4 x Potelet | Cdwk_ProdNb: 156 / Cdwk_MatName: Acier 4.6
3 x Arbal?trier | Cdwk_ProdNb: 145 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 177 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 193 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 32 / Cdwk_MatName: Acier 4.6
5 x Poteau | Cdwk_ProdNb: 142 / Cdwk_MatName: Acier 4.6
4 x Lisse | Cdwk_ProdNb: 123 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 14 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 114 / Cdwk_MatName: Acier 4.6
Montant | Cdwk_ProdNb: 153 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 105 / Cdwk_MatName: Acier 4.6
3 x Suspente | Cdwk_ProdNb: 62 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 33 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 17 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 124 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 185 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 36 / Cdwk_MatName: Acier 4.6
3 x Panne | Cdwk_ProdNb: 167 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 28 / Cdwk_MatName: Acier 4.6
4 x Traverse | Cdwk_ProdNb: 197 / Cdwk_MatName: Acier 4.6
4 x Plat m?tallique | Cdwk_ProdNb: 2 / Cdwk_MatName: Acier 4.6
3 x Suspente | Cdwk_ProdNb: 64 / Cdwk_MatName: Acier 4.6
3 x Lisse | Cdwk_ProdNb: 132 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 125 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 46 / Cdwk_MatName: Acier 4.6
9 x Main courante | Cdwk_ProdNb: 16 / Cdwk_MatName: Acier 4.6
4 x Lisse | Cdwk_ProdNb: 115 / Cdwk_MatName: Acier 4.6
4 x Panne | Cdwk_ProdNb: 166 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 37 / Cdwk_MatName: Acier 4.6
3 x Lisse | Cdwk_ProdNb: 133 / Cdwk_MatName: Acier 4.6
3 x Poteau | Cdwk_ProdNb: 1 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 50 / Cdwk_MatName: Acier 4.6
3 x Buton | Cdwk_ProdNb: 121 / Cdwk_MatName: Acier 4.6
Membrure Haute | Cdwk_ProdNb: 162 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 148 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 112 / Cdwk_MatName: Acier 4.6
4 x Membrure Haute | Cdwk_ProdNb: 158 / Cdwk_MatName: Acier 4.6
12 x Support bardage | Cdwk_ProdNb: 71 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 19 / Cdwk_MatName: Acier 4.6
3 x Arbal?trier | Cdwk_ProdNb: 165 / Cdwk_MatName: Acier 4.6
Membrure Haute | Cdwk_ProdNb: 159 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 182 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 101 / Cdwk_MatName: Acier 4.6
2 x Montant | Cdwk_ProdNb: 95 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 111 / Cdwk_MatName: Acier 4.6
3 x Panne | Cdwk_ProdNb: 169 / Cdwk_MatName: Acier 4.6
6 x Lisse | Cdwk_ProdNb: 94 / Cdwk_MatName: Acier 4.6
2 x Suspente | Cdwk_ProdNb: 60 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 31 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 66 / Cdwk_MatName: Acier 4.6
3 x Poteau | Cdwk_ProdNb: 4 / Cdwk_MatName: Acier 4.6
4 x Potelet | Cdwk_ProdNb: 154 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 84 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 135 / Cdwk_MatName: Acier 4.6
4 x Panne | Cdwk_ProdNb: 86 / Cdwk_MatName: Acier 4.6
3 x Poteau | Cdwk_ProdNb: 12 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 68 / Cdwk_MatName: Acier 4.6
5 x Montant | Cdwk_ProdNb: 155 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 55 / Cdwk_MatName: Acier 4.6
3 x Caillebotis | Cdwk_ProdNb: 0 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 15 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 175 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 146 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 38 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 110 / Cdwk_MatName: Acier 4.6
Membrure basse | Cdwk_ProdNb: 161 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 172 / Cdwk_MatName: Acier 4.6
2 x Diagonale | Cdwk_ProdNb: 103 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 180 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 186 / Cdwk_MatName: Acier 4.6
Arbal?trier | Cdwk_ProdNb: 149 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 65 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 6 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 136 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 116 / Cdwk_MatName: Acier 4.6
5 x Poteau | Cdwk_ProdNb: 3 / Cdwk_MatName: Acier 4.6
Longeron | Cdwk_ProdNb: 58 / Cdwk_MatName: Acier 4.6
Main courante | Cdwk_ProdNb: 21 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 201 / Cdwk_MatName: Acier 4.6
Suspente | Cdwk_ProdNb: 61 / Cdwk_MatName: Acier 4.6
2 x Diagonale | Cdwk_ProdNb: 81 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 48 / Cdwk_MatName: Acier 4.6
4 x Traverse | Cdwk_ProdNb: 198 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 118 / Cdwk_MatName: Acier 4.6
2 x Montant | Cdwk_ProdNb: 96 / Cdwk_MatName: Acier 4.6
2 x Support bardage | Cdwk_ProdNb: 72 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 39 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 35 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 192 / Cdwk_MatName: Acier 4.6
2 x Longeron | Cdwk_ProdNb: 59 / Cdwk_MatName: Acier 4.6
3 x Longeron | Cdwk_ProdNb: 27 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 91 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 7 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 176 / Cdwk_MatName: Acier 4.6
4 x Potelet | Cdwk_ProdNb: 157 / Cdwk_MatName: Acier 4.6
2 x Poteau | Cdwk_ProdNb: 5 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 77 / Cdwk_MatName: Acier 4.6
3 x Panne | Cdwk_ProdNb: 181 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 203 / Cdwk_MatName: Acier 4.6
Dalle | Cdwk_ProdNb: 0 / Cdwk_MatName: B?ton
2 x Diagonale | Cdwk_ProdNb: 78 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 67 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 98 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 34 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 10 / Cdwk_MatName: Acier 4.6
3 x Main courante | Cdwk_ProdNb: 13 / Cdwk_MatName: Acier 4.6
3 x Lisse | Cdwk_ProdNb: 92 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 127 / Cdwk_MatName: Acier 4.6
3 x Arbal?trier | Cdwk_ProdNb: 144 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 43 / Cdwk_MatName: Acier 4.6
2 x Lisse acrot?re | Cdwk_ProdNb: 139 / Cdwk_MatName: Acier 4.6
2 x Main courante | Cdwk_ProdNb: 22 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 199 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 70 / Cdwk_MatName: Acier 4.6
3 x Lisse | Cdwk_ProdNb: 128 / Cdwk_MatName: Acier 4.6
3 x Poteau | Cdwk_ProdNb: 202 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 113 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 80 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 42 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 108 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 200 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 138 / Cdwk_MatName: Acier 4.6
Plat m?tallique | Cdwk_ProdNb: 170 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 29 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 85 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 130 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 53 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 195 / Cdwk_MatName: Acier 4.6
3 x Panne | Cdwk_ProdNb: 141 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 184 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 179 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 52 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 131 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 76 / Cdwk_MatName: Acier 4.6
2 x Lisse | Cdwk_ProdNb: 30 / Cdwk_MatName: Acier 4.6
Poutre | Cdwk_ProdNb: 164 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 87 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 47 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 40 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 173 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 107 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 183 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 196 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 83 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 79 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 88 / Cdwk_MatName: Acier 4.6
Ramasse pannes | Cdwk_ProdNb: 69 / Cdwk_MatName: Acier 4.6
2 x Traverse | Cdwk_ProdNb: 178 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 129 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 8 / Cdwk_MatName: Acier 4.6
Montant | Cdwk_ProdNb: 152 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 117 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 99 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 89 / Cdwk_MatName: Acier 4.6
Traverse | Cdwk_ProdNb: 171 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 102 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 73 / Cdwk_MatName: Acier 4.6
Main courante | Cdwk_ProdNb: 23 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 106 / Cdwk_MatName: Acier 4.6
Lisse | Cdwk_ProdNb: 45 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 147 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 90 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 188 / Cdwk_MatName: Acier 4.6
Diagonale | Cdwk_ProdNb: 126 / Cdwk_MatName: Acier 4.6
Buton | Cdwk_ProdNb: 104 / Cdwk_MatName: Acier 4.6
Murailli?re | Cdwk_ProdNb: 51 / Cdwk_MatName: Acier 4.6
Poteau | Cdwk_ProdNb: 187 / Cdwk_MatName: Acier 4.6
2 x Main courante | Cdwk_ProdNb: 18 / Cdwk_MatName: Acier 4.6
Montant | Cdwk_ProdNb: 151 / Cdwk_MatName: Acier 4.6
Membrure Haute | Cdwk_ProdNb: 160 / Cdwk_MatName: Acier 4.6
Lisse acrot?re | Cdwk_ProdNb: 134 / Cdwk_MatName: Acier 4.6
Membrure Haute | Cdwk_ProdNb: 150 / Cdwk_MatName: Acier 4.6

# IfcBuildingElementProxy (20)
In: __Cdwk_Undefined__
Description: Cdwk_ProdNb: 0 / Cdwk_MatName: Sapin
